## drivers/mihw/Kconfig
```kconfig
config GAEA
	tristate "low end scheduler"
	depends on GAEA_WALT
	help
	  low end scheduler
```
